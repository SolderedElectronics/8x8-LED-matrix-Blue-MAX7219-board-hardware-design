# Repository SolderedElectronics/8x8-LED-matrix-Blue-MAX7219-board-hardware-design

File README.md:

# 8x8 LED matrix Blue MAX7219 board Hardware Design

## About the Product

|  |
| :----------------------------------------------------------: |
| [Buy 8x8 LED matrix Blue MAX7219 board](https://www.solde.red/333153) |

The LED matrix 8×8 is a system of 64 interconnected LEDs that, with the help of the MAX7219 LED driver, light up as programmed, and all of this is located on one board and is truly easy to use. You can use them to show letters or symbols, display text, and the like. It is possible to connect several modules with just a few wires and control several matrices at once.

The design of the modules is such that they will look like they are from one piece, even if you stack several of them one after the other. The LEDs on the board are beautiful 0402 very small LEDs and give a very nice effect when lit.

---

## Repository Contents

This repository contains all design files for 8x8 LED matrix Blue MAX7219 board, organized as follows:

- **`CAD` folder**: Contains KiCAD design files, including:
  - Schematics
  - PCB layout
  - Panel PCB layout
  - Source 3D files in Fusion360, if any
  - All files are sorted by version with a detailed change log.
- **`OUTPUTS` folder**: Includes all production-ready files, such as:
  - Bill of Materials (BOM) and interactive BOM (iBOM)
  - PDF versions of schematics
  - 3D `.step` file of the board
  - 3D-printable models
  - Gerber files for PCB manufacturing
  - Image of the pinout of the board
  - Product image
  - Compliance, legal and generic sales documents

Refer to the `Change Log` in the CAD folder for details about updates between versions.

---

## Learn More About the Product

Beyond the repository, explore the following resources:

### Soldered Verify

The **Soldered Verify** system ensures every board you purchase from Soldered is fully functional. It also provides access to exclusive test data for your product. To get started, find the unique Soldered Verify ID on your product's packaging and enter the ID on the [Soldered Verify page](https://soldered.com/verify/) to access test results and additional product details.

### Soldered Community

Soldered Community is your go-to place for technical support. Our engineers track and answer all questions posted there, and it’s a great space for the maker community. Get answers to your questions and solutions for your challenges at [Soldered Community](https://soldered.com/community).

### solde.red

solde.red is an ultimate URL shortener and information hub. Access it by typing solde.red/ followed by your product SKU, e.g., [solde.red/333000](https://solde.red/333000), to find getting-started guides, datasheets, open-source hardware and software files, certifications, images, pinouts, and more. Read more about the shortener [here](https://solde.red/info/).

---

## Contributing

Contributions are welcome! Here’s how you can get involved:

- Submit pull requests to enhance the design or fix issues.
- Report bugs or problems by opening an issue.

We encourage community collaboration to make this product even better.

---

## About Soldered

[Soldered for Makers](https://soldered.com) specializes in designing and manufacturing electronic products tailored for enthusiasts, ranging from hobbyists to professionals. Our portfolio includes electronic boards, sensors, and actuators that are widely utilized in fields such as microelectronics, mechatronics, robotics, programming, and IoT. Every product we offer is designed in-house and built upon open-source hardware and software platforms. Proudly certified and manufactured within the European Union, our catalog likely includes the product you need for your project.

We complement these products with comprehensive tutorials and manuals, product descriptions, schematics, programming codes, and project examples. Our round-the-clock [customer and technical support](https://soldered.com/community) is available for all our products, irrespective of the sales channel. Soldered’s success and services reflect our maker community’s unwavering [trust](https://www.trustpilot.com/review/soldered.com), for which we are deeply grateful. Join our community and create using Soldered products.

---

## License

All Soldered open-source hardware (OSH) is under The TAPR Open Hardware License. Read more in the LICENSE file located in this repository.

**Disclaimer:**

No warranty - all designs in this repository are distributed in the hope that they will be useful, but without any warranty. They are provided "AS IS", therefore without warranty of any kind, either expressed or implied. The entire quality and performance of what you do with the contents of this repository are your responsibility. In no event Soldered Electronics will be liable for your damages, or losses, including any general, special, incidental, or consequential damage arising out of the use or inability to use the contents of this repository. 

---

## Have fun!

Thank you for your support from your fellow makers at Soldered Electronics.

Happy Making!

## KiCad design CAD/V1.0.0/LED MATRIX MAX7219.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64: 0402LED
FD1: FIDUCIAL; FIDUCIAL_23
H1, H2: HOLE_3.2mm
K1, K2: HEADER_MALE_5X1
R1: 22k; 0603R
U1: MAX7219CWG+; SOIC-24

Connections:
CLK: K1.1, K2.1, U1.13 (CLK)
DIN: K1.3, U1.1 (DIN)
DOUT: K2.3, U1.24 (DOUT)
GND: K1.4, K2.4, U1.4 (GND), U1.9 (GND)
LOAD: K1.2, K2.2, U1.12 (LOAD)
unnamed: D1.1 (A), D9.1 (A), D17.1 (A), D25.1 (A), D33.1 (A), D41.1 (A), D49.1 (A), D57.1 (A), U1.14 (SEGA)
unnamed: D1.2 (K), D2.2 (K), D3.2 (K), D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), D8.2 (K), U1.2 (DIG0)
unnamed: D2.1 (A), D10.1 (A), D18.1 (A), D26.1 (A), D34.1 (A), D42.1 (A), D50.1 (A), D58.1 (A), U1.16 (SEGB)
unnamed: D9.2 (K), D10.2 (K), D11.2 (K), D12.2 (K), D13.2 (K), D14.2 (K), D15.2 (K), D16.2 (K), U1.11 (DIG1)
unnamed: D3.1 (A), D11.1 (A), D19.1 (A), D27.1 (A), D35.1 (A), D43.1 (A), D51.1 (A), D59.1 (A), U1.20 (SEGC)
unnamed: D4.1 (A), D12.1 (A), D20.1 (A), D28.1 (A), D36.1 (A), D44.1 (A), D52.1 (A), D60.1 (A), U1.23 (SEGD)
unnamed: D5.1 (A), D13.1 (A), D21.1 (A), D29.1 (A), D37.1 (A), D45.1 (A), D53.1 (A), D61.1 (A), U1.21 (SEGE)
unnamed: D6.1 (A), D14.1 (A), D22.1 (A), D30.1 (A), D38.1 (A), D46.1 (A), D54.1 (A), D62.1 (A), U1.15 (SEGF)
unnamed: D7.1 (A), D15.1 (A), D23.1 (A), D31.1 (A), D39.1 (A), D47.1 (A), D55.1 (A), D63.1 (A), U1.17 (SEGG)
unnamed: D8.1 (A), D16.1 (A), D24.1 (A), D32.1 (A), D40.1 (A), D48.1 (A), D56.1 (A), D64.1 (A), U1.22 (SEGDP)
unnamed: D17.2 (K), D18.2 (K), D19.2 (K), D20.2 (K), D21.2 (K), D22.2 (K), D23.2 (K), D24.2 (K), U1.6 (DIG2)
unnamed: D25.2 (K), D26.2 (K), D27.2 (K), D28.2 (K), D29.2 (K), D30.2 (K), D31.2 (K), D32.2 (K), U1.7 (DIG3)
unnamed: D33.2 (K), D34.2 (K), D35.2 (K), D36.2 (K), D37.2 (K), D38.2 (K), D39.2 (K), D40.2 (K), U1.3 (DIG4)
unnamed: D41.2 (K), D42.2 (K), D43.2 (K), D44.2 (K), D45.2 (K), D46.2 (K), D47.2 (K), D48.2 (K), U1.10 (DIG5)
unnamed: D49.2 (K), D50.2 (K), D51.2 (K), D52.2 (K), D53.2 (K), D54.2 (K), D55.2 (K), D56.2 (K), U1.5 (DIG6)
unnamed: D57.2 (K), D58.2 (K), D59.2 (K), D60.2 (K), D61.2 (K), D62.2 (K), D63.2 (K), D64.2 (K), U1.8 (DIG7)
unnamed: R1.1, U1.18 (ISET)
VCC: K1.5, K2.5, R1.2, U1.19 (V+)

Notes on the sheet:
HEADER
MAX7219 DRIVER WITH LEDS

Board: 2 copper layers, 22.0 x 54.0 mm, 72 parts (3 on the bottom side), 23 nets.

Other parts of the board:
Ref**: Val**; Version1.0.0.

## Commit log

2022-08-06 Updating open source files.
